# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARM_Compiler_5.06u7)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\Library;.\User;.\system;.\Hardware;.\FreeRTOS\include;.\FreeRTOS\RVDS\ARM_CM3;.\FatFs
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x1b000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./system/: Timer.h
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group system
    ./system/: Timer.c DWT_Delay.c DWT_Delay.h
  group Hardware
    ./Hardware/: HC_SR04.c HC_SR04.h buzz.c buzz.h LightSensor.c LightSensor.h OLED.c OLED.h OLED_Font.h Key.c Key.h Serial.c Serial.h MPU6050.c MPU6050.h MPU6050_Reg.h MyI2C.c MyI2C.h AD.c AD.h SD_SPI.c SD_SPI.h DS18B20.c DS18B20.h BMP280.c BMP280.h MyRTC.c MyRTC.h Crc16.c Crc16.h DHT22.c DHT22.h W25Q64.c W25Q64.h
  group FatFs
    ./FatFs/: ff.c ff.h diskio.h diskio_spi.c
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h freertos_demo.c task_sd.c task_sd.h can_tx.c can_tx.h iso_tp.c iso_tp.h uds.c uds.h ota_stage.c ota_stage.h i2c_link.c i2c_link.h ProbeConfig.h golden.c golden.h boot_param.c boot_param.h
  group FreeRTOS_Source
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS/include/: FreeRTOSConfig.h
  group FreeRTOS_Port
    ./FreeRTOS/RVDS/ARM_CM3/: port.c
  group freeRTOS_Heap
    ./FreeRTOS/MemMang/: heap_4.c
